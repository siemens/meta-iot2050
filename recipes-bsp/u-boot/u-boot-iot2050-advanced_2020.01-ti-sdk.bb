#
# Copyright (c) Siemens AG, 2021
#
# Authors:
#  Chao Zeng <chao.zeng@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

IOT2050_VARIANT = "advanced"

require u-boot-iot2050-${PV}.inc
