#
# Copyright (c) Siemens AG, 2020-2022
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

inherit npm

DESCRIPTION = "node red mindconnect node using mindconnect-nodejs library"

NPMPN = "@mindconnect/node-red-contrib-mindconnect"
NPM_LOCAL_INSTALL_DIR = "/root/.node-red"
