#
# Copyright (c) Siemens AG, 2020
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

inherit npm

DESCRIPTION = "A Node-RED node to interact with Siemens S7 PLCs"

NPM_LOCAL_INSTALL_DIR = "/root/.node-red"
