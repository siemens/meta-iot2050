#
# Copyright (c) Siemens AG, 2023-2024
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

DESCRIPTION = "IOT2050 swupdate image customizations"

MACHINE_HW_VERSION = "IOT2050"
