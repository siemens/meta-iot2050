# Copyright (c) Siemens AG, 2026
# SPDX-License-Identifier: MIT

inherit npm
inherit node-red-module

NPMPN = "@flowfuse/node-red-dashboard"
DESCRIPTION = "Maintained FlowFuse Dashboard for Node-RED"
