#
# Copyright (c) Siemens AG, 2023-2026
#
# Authors:
#  Su Bao Cheng <baocheng.su@siemens.com>
#  Li Hua Qian <huaqian.li@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

inherit optee-os-tadevkit
require optee-os-iot2050_${PV}.inc
