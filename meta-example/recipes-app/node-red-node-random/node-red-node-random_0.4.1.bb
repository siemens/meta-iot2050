#
# Copyright (c) Siemens AG, 2023-2025
#
# Authors:
#  Li Hua Qian <huaqian.li@siemens.com>
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

PR = "1"

inherit npm
inherit node-red-module

DESCRIPTION = "A set of random nodes for Node-RED"
