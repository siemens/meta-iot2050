#
# Copyright (c) Siemens AG, 2018-2023
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

require linux-iot2050-6.1.inc

SRC_URI[sha256sum] = "8c9cb5edc7318cdf8b50594003934bb1465ab8aabc76393f5f402690b2c1f071"

SRC_URI += "file://iot2050-rt.cfg"
