#
# Copyright (c) Siemens AG, 2018-2023
#
# This file is subject to the terms and conditions of the MIT License.  See
# COPYING.MIT file in the top-level directory.
#

require linux-iot2050-6.1.inc

SRC_URI[sha256sum] = "431498a219a445a17b79c7a4467dda912e4a31e1add35684aa6e36483c898304"
